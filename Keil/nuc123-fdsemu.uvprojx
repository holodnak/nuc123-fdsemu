# Keil uVision project nuc123-fdsemu.uvprojx, settings and files
target nuc123-fdsemu (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: NUC123LD4AN0 Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.5
  cpu: IROM(0x00000000,0x11000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: nuc123-fdsemu +hex
  BeforeMake: incbuild.exe ../build.h
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 oTime=1 OneElfS=1
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\NUC123\Include;..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC123.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../Library/Device/Nuvoton/NUC123/Source/: system_NUC123.c
    ../Library/Device/Nuvoton/NUC123/Source/ARM/: startup_NUC123.s
  group User
    ../: main.c flash.c spiutil.c fds.c sram.c descriptors.c hid_transfer.c fdsutil.c diskrw.c fifo.c transfer.c loader_lz4.c loader.c crc32.c
  group Library
    ../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c spi.c timer.c gpio.c usbd.c fmc.c
software components: CMSIS:CORE 4.3.0
